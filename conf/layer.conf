## conf/layer.conf
```bitbake
LAYERNAME = "meta-riscv"

LAYERSERIES_COMPAT = "garburn"

SIGGEN_EXCLUDERECIPES_ABISAFE += " \
    mesa-pvr \
"
```
